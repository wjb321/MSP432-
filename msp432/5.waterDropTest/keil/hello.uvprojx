# Keil uVision project hello.uvprojx, settings and files
target hello (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MSP432E401Y Texas Instruments
  pack: TexasInstruments.MSP432E4_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00040000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: hello
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ../../../../../../source;../../../../../../source/third_party/CMSIS/Include/;..\APP;C:\ti\simplelink_msp432e4_sdk_4_20_00_12\source;C:\ti\simplelink_msp432e4_sdk_4_20_00_12\source\third_party\CMSIS\Include
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source
    ../: hello.c system_msp432e401y.c
    ./: startup_msp432e401y_uvision.s
    ../APP/: pinout.c uartstdio.c oled.c delay.c uart.c key.c timer.c sd01.c led.c
  group Library
    C:/ti/simplelink_msp432e4_sdk_4_20_00_12/source/ti/devices/msp432e4/driverlib/lib/keil/m4f/: msp432e4_driverlib.a
software components: CMSIS:CORE 5.0.1
