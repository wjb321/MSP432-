# Keil uVision project blinky.uvprojx, settings and files
target blinky (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MSP432E401Y Texas Instruments
  pack: TexasInstruments.MSP432E4_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00040000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: blinky +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: C:\ti\simplelink_msp432e4_sdk_4_20_00_12\source;C:\ti\simplelink_msp432e4_sdk_4_20_00_12\source\third_party\CMSIS\Include;..\led;..\usart;..\delay;..\driverlib;..\timer;C:\ti\simplelink_msp432e4_sdk_4_20_00_12\source\ti\devices\msp432e4\driverlib\inc;F:\FreeRTOSv202212.00\FreeRTOS\Source\include;F:\FreeRTOSv202212.00\FreeRTOS\Source\portable\RVDS\ARM_CM4F;F:\FreeRTOSv202212.00\FreeRTOS-Plus\Source\FreeRTOS-Plus-CLI;..\keil;..\Driver_Libs
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source
    ../: blinky.c system_msp432e401y.c
    ./: startup_msp432e401y_uvision.s
  group Library
    C:/ti/simplelink_msp432e4_sdk_4_20_00_12/source/ti/devices/msp432e4/driverlib/lib/keil/m4f/: msp432e4_driverlib.a
  group Usart
    ../usart/: uartstdio.c usart.c
  group Led
    ../led/: pinout.c
  group Delay
    ../delay/: delay.c
  group Timer
    ../driverlib/: timer.c
    ../timer/: timers_config.c
  group FreeRTOS_Source
    F:/FreeRTOSv202212.00/FreeRTOS/Source/: event_groups.c list.c queue.c tasks.c timers.c
    F:/FreeRTOSv202212.00/FreeRTOS/Source/portable/MemMang/: heap_4.c
    F:/FreeRTOSv202212.00/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Drive_Libs
    ../Driver_Libs/: gpio.c
software components: CMSIS:CORE 5.0.1
