# Keil uVision project blinky.uvprojx, settings and files
target blinky (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: MSP432E401Y Texas Instruments
  pack: TexasInstruments.MSP432E4_DFP.3.2.6
  cpu: IRAM(0x20000000,0x00040000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: blinky +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: C:\ti\simplelink_msp432e4_sdk_4_20_00_12\source;C:\ti\simplelink_msp432e4_sdk_4_20_00_12\source\third_party\CMSIS\Include;..\uart;..\LcdDriver;..\src\fonts;..\src\grlib;..\src\image-reformer
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Source
    ../: blinky.c system_msp432e401y.c pinout.c
    ./: startup_msp432e401y_uvision.s
  group Library
    C:/ti/simplelink_msp432e4_sdk_4_20_00_12/source/ti/devices/msp432e4/driverlib/lib/keil/m4f/: msp432e4_driverlib.a
  group uart
    ../uart/: uartstdio.c
  group lcd
    ../LcdDriver/: HAL_MSP_EXP432P401R_KITRONIX320X240_SSD2119_SPI.c kitronix320x240x16_ssd2119_spi.c
    ../: touch_E401Y.c
software components: CMSIS:CORE 5.6.0, Compiler:I/O:STDERR 1.2.0, RTOS:kernel 3.1.5, RTOS:shell 3.1.5
